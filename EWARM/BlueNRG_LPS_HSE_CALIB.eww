<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\BlueNRG_LPS_HSE_CALIB.ewp</path>
    </project>
    <batchBuild />
</workspace>
